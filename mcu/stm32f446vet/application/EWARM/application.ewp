# IAR project application.ewp, settings and files
configuration application (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446VE ST STM32F446VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Middlewares\ST\STemWin\Config; ..\Middlewares\ST\STemWin\inc; ..\Drivers\BSP\STM32446e_eval; ..\Drivers\BSP\Components
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: application.bin
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: stm32f446xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f446xx.s
  group Application/Font
    ../Font/: City18.c PF42.c PF48.c WQY14.c WQY16.c WQY18.c WQY20.c WQY22.c WQY24.c WQY26.c
  group Application/Icon
    ../Icon/: icon_1jia.c icon_360.c icon_asus.c icon_coolpad.c icon_default.c icon_dell.c icon_download_gray.c icon_download_white.c icon_haier.c icon_hasee.c icon_hint_disconnected.c icon_honor.c icon_hp.c icon_htc.c icon_huawei.c icon_information_background_double.c icon_information_background_single.c icon_iPhone.c icon_lenovo.c icon_letv.c icon_lg.c icon_locationfailed.c icon_meitu.c icon_meizu.c icon_oppo.c icon_phicomm.c icon_recovery.c icon_samsung.c icon_smartisan.c icon_soft_update.c icon_sony.c icon_tcl.c icon_thinkpad.c icon_tongfang.c icon_two_dimensional_code.c icon_upgrade.c icon_upload_gray.c icon_upload_white.c icon_usb_link.c icon_visitor.c icon_vivo.c icon_wifi.c icon_windowsphone.c icon_xiaomi.c icon_zte.c phicomm_logo.c w_cloudy.c w_dust.c w_foggy.c w_haze.c w_overcast.c w_rain.c w_snow.c w_sun.c w_unknown.c w_windy.c
  group Application/User
    ../Src/: app.c main.c mcu_st.c mcu_ui.c stm32f4xx_hal_msp.c stm32f4xx_it.c uhmi_common.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/CY8CMBR3108/: CY8CMBR3108.c
    ../Drivers/BSP/Components/ili9488/: ili9488.c
    ../Drivers/BSP/Components/myiic/: myiic.c
  group Drivers/BSP/stm32f446e_eval
    ../Drivers/BSP/STM32446e_eval/: stm32446e_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c
  group Middlewares/STemWin/Config
    ../Middlewares/ST/STemWin/OS/: GUI_X.c
    ../Src/: GUIConf_stm32446e_eval.c LCDConf_stm32446e_eval.c
  group Middlewares/STemWin/Lib
    ../Middlewares/ST/STemWin/Lib/: STemWin532_CM4_IAR.a
